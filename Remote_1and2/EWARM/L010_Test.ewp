# IAR project L010_Test.ewp, settings and files
configuration L010_Test (ARM, debug)
  General.OGChipSelectEditMenu: STM32L010K4 ST STM32L010K4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L010x4
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; $TOOLKIT_DIR$\..\..\..\..\Users\VinDa\OneDrive\Documents\IAR\ELEN509_SQ22\L010_Test\Core\Modules\Conversions; ..\Core\Modules\Serial; ..\Core\Modules\SevenSegLED; ..\Core\Modules\Conversions
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L010_Test.hex
  ILINK.IlinkOutputFile: L010_Test.out
  ILINK.IlinkIcfFile: stm32l010x4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l010x4.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Application/User/Modules
    ../Core/Modules/Conversions/: ASCII_numbers.c
    ../Core/Modules/Serial/: Serial.c serial_user.c
    ../Core/Modules/SevenSegLED/: SevenSegLED.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_ll_lpuart.c
